Commit message: action client

File: urdf/ball.xacro (robot description, xacro)
@@ -36,5 +36,5 @@
     <collision name="collision_ball">
       <geometry>
-       <!-- <sphere radius="0.5"/>-->
+      <!-- <sphere radius="0.5"/>-->
       </geometry>
     </collision>
